v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/reram_cell.sym} -40 0 0 0 {name=R1
model=reram_cell
Tfilament_0=3.3e-9
spiceprefix=X
}
